#include "iching_data.h"

namespace {
constexpr IChingHexagram kHexagramsById[] = {
    {0, "", "", "", "", "", "", "", ""},
    {1, "乾为天", "111111", "乾", "乾", "元亨利贞。", "主动开创，气势充足，适合开始与推进；注意不要过刚。", "趋势走向更强的主动性与担当，宜自强但忌骄亢。", "创造 / 领导 / 自强 / 过刚"},
    {2, "坤为地", "000000", "坤", "坤", "元亨，利牝马之贞。", "承载、配合、顺势而为，适合稳住局面，不宜强出头。", "趋势走向包容与稳定，宜耐心承接、以柔克刚。", "承载 / 顺势 / 包容 / 稳定"},
    {3, "水雷屯", "100010", "坎", "震", "元亨利贞，勿用有攸往，利建侯。", "万事初生而艰难，先立基础，别急着扩张。", "变化后的重点是破土初生，先解决混乱与阻力。", "初始 / 困难 / 蓄势 / 建基"},
    {4, "山水蒙", "010001", "艮", "坎", "亨，匪我求童蒙，童蒙求我。", "信息不足、经验尚浅，需要学习、请教与建立规则。", "趋势走向启蒙与学习，先弄懂问题再行动。", "启蒙 / 学习 / 不明 / 规矩"},
    {5, "水天需", "111010", "坎", "乾", "有孚，光亨，贞吉。利涉大川。", "条件未足，需要等待时机；保持信心，准备充分。", "趋势要求等待与蓄势，耐住性子会更有利。", "等待 / 蓄势 / 信心 / 时机"},
    {6, "天水讼", "010111", "乾", "坎", "有孚窒惕，中吉，终凶。", "有争议与对立，宜止争求中，不宜硬刚到底。", "趋势走向冲突与辩争，宜及时沟通、留有退路。", "争执 / 边界 / 沟通 / 止争"},
    {7, "地水师", "010000", "坤", "坎", "贞，丈人吉，无咎。", "组织力量、统一纪律，适合团队行动但要有良将。", "趋势需要组织与纪律，适合集中资源解决问题。", "组织 / 纪律 / 团队 / 执行"},
    {8, "水地比", "000010", "坎", "坤", "吉。原筮，元永贞，无咎。", "亲近、结盟、寻找同道；关键是选择可靠关系。", "趋势走向结盟与依附，宜寻找可信伙伴。", "亲近 / 结盟 / 归属 / 合作"},
    {9, "风天小畜", "111011", "巽", "乾", "亨。密云不雨，自我西郊。", "力量尚小，只能小幅积累与约束，暂难大成。", "趋势是小有积蓄，先做微调和准备。", "小成 / 积累 / 约束 / 未雨"},
    {10, "天泽履", "110111", "乾", "兑", "履虎尾，不咥人，亨。", "处在危险边界上，谨慎守礼可通行。", "趋势要求谨慎行事，守规则比冒进更重要。", "谨慎 / 礼法 / 风险 / 分寸"},
    {11, "地天泰", "111000", "坤", "乾", "小往大来，吉亨。", "上下交通，局面通畅，是顺势发展之象。", "趋势走向通达与协调，适合推进合作。", "通泰 / 顺畅 / 协同 / 成长"},
    {12, "天地否", "000111", "乾", "坤", "否之匪人，不利君子贞。", "上下隔绝，沟通不畅，宜守正等待转机。", "趋势走向阻滞闭塞，需要先打通沟通。", "闭塞 / 隔绝 / 停滞 / 守正"},
    {13, "天火同人", "101111", "乾", "离", "同人于野，亨。利涉大川。", "公开结伴、求同存异，适合共同目标下合作。", "趋势走向开放协作，宜扩大共识。", "同道 / 公开 / 合作 / 共识"},
    {14, "火天大有", "111101", "离", "乾", "元亨。", "资源充足、成果显现，宜善用丰盛而不炫耀。", "趋势走向丰盛与拥有，宜守住德性和节制。", "丰盛 / 资源 / 成果 / 节制"},
    {15, "地山谦", "001000", "坤", "艮", "亨，君子有终。", "谦逊能聚人心，低姿态反而有长期收益。", "趋势要求谦逊收敛，稳扎稳打。", "谦逊 / 低调 / 稳健 / 有终"},
    {16, "雷地豫", "000100", "震", "坤", "利建侯行师。", "情绪被调动，适合动员与计划，但别沉迷安逸。", "趋势走向动员和预备，宜把热情转成行动。", "预备 / 动员 / 喜悦 / 行动"},
    {17, "泽雷随", "100110", "兑", "震", "元亨利贞，无咎。", "随势而动、顺应变化，跟随可信方向。", "趋势要求顺势调整，跟随正确节奏。", "跟随 / 适应 / 顺势 / 响应"},
    {18, "山风蛊", "011001", "艮", "巽", "元亨，利涉大川。先甲三日，后甲三日。", "旧问题积弊已久，需要修复、整顿与重建。", "趋势指向整顿旧弊，先清理再前进。", "整顿 / 修复 / 积弊 / 重建"},
    {19, "地泽临", "110000", "坤", "兑", "元亨利贞。至于八月有凶。", "机会靠近，适合主动临近、关照与管理。", "趋势走向接近与扩张，宜把握窗口期。", "临近 / 机会 / 管理 / 扩展"},
    {20, "风地观", "000011", "巽", "坤", "盥而不荐，有孚颙若。", "先观察全局、建立视角，不急于下判断。", "趋势要求观察与审视，从更高处看问题。", "观察 / 审视 / 格局 / 等待"},
    {21, "火雷噬嗑", "100101", "离", "震", "亨，利用狱。", "有阻隔需咬断，适合明确规则、处理障碍。", "趋势走向处理阻碍，宜果断清理问题。", "障碍 / 规则 / 惩戒 / 突破"},
    {22, "山火贲", "101001", "艮", "离", "亨，小利有攸往。", "修饰、包装、礼仪能增色，但不要重表轻里。", "趋势走向美化与呈现，宜内外兼顾。", "装饰 / 表达 / 礼仪 / 美感"},
    {23, "山地剥", "000001", "艮", "坤", "不利有攸往。", "基础被剥蚀，局面下行，宜保守止损。", "趋势走向剥落与收缩，先护住根基。", "剥落 / 衰退 / 止损 / 守护"},
    {24, "地雷复", "100000", "坤", "震", "亨。出入无疾，朋来无咎。", "阳气初回，适合重新开始，慢慢恢复。", "趋势出现回归与复苏，宜小步重启。", "返回 / 复苏 / 重启 / 循环"},
    {25, "天雷无妄", "100111", "乾", "震", "元亨利贞。其匪正有眚。", "保持真诚自然，不妄动，不做不正之事。", "趋势要求真诚不妄，顺其自然。", "真实 / 自然 / 不妄 / 守正"},
    {26, "山天大畜", "111001", "艮", "乾", "利贞，不家食吉，利涉大川。", "大规模蓄积与克制，准备成熟后可有大行动。", "趋势走向大蓄积，先储备能力再突破。", "蓄积 / 克制 / 实力 / 准备"},
    {27, "山雷颐", "100001", "艮", "震", "贞吉。观颐，自求口实。", "关注养分、表达与输入输出，先养正自己。", "趋势关注滋养与选择输入，慎言慎食。", "滋养 / 口舌 / 输入 / 自养"},
    {28, "泽风大过", "011110", "兑", "巽", "栋桡，利有攸往，亨。", "压力过重、结构失衡，需要非常手段调整。", "趋势走向过载与突破，宜重构承重。", "过载 / 非常 / 压力 / 重构"},
    {29, "坎为水", "010010", "坎", "坎", "习坎，有孚，维心亨，行有尚。", "连续险阻中保持内心诚实，稳步通过。", "趋势进入险中求通，信念与谨慎最重要。", "险阻 / 重复 / 信念 / 谨慎"},
    {30, "离为火", "101101", "离", "离", "利贞，亨。畜牝牛吉。", "光明、依附、看见真相；宜守正而不浮躁。", "趋势走向显现与照明，事实会被看见。", "光明 / 显现 / 依附 / 清晰"},
    {31, "泽山咸", "001110", "兑", "艮", "亨，利贞，取女吉。", "感应、吸引、情感互动，宜真诚回应。", "趋势走向感应与吸引，关系开始互动。", "感应 / 吸引 / 情感 / 回应"},
    {32, "雷风恒", "011100", "震", "巽", "亨，无咎，利贞。", "长期稳定、持续经营，贵在恒心与节奏。", "趋势要求持续与稳定，别三分钟热度。", "恒久 / 坚持 / 稳定 / 节奏"},
    {33, "天山遁", "001111", "乾", "艮", "亨，小利贞。", "适当退避，保存实力，不与强势正面冲突。", "趋势走向退守，退一步是策略不是失败。", "退避 / 保存 / 策略 / 远离"},
    {34, "雷天大壮", "111100", "震", "乾", "利贞。", "力量强盛，适合推进，但要守正不逞强。", "趋势走向强势增长，需防止用力过猛。", "强盛 / 推进 / 力量 / 守正"},
    {35, "火地晋", "000101", "离", "坤", "康侯用锡马蕃庶，昼日三接。", "上升、晋级、被看见，适合展示成果。", "趋势走向上升与被认可，宜积极表现。", "晋升 / 显达 / 认可 / 前进"},
    {36, "地火明夷", "101000", "坤", "离", "利艰贞。", "光明受伤，环境不利，宜韬光养晦。", "趋势走向隐藏与保护，保住内在光明。", "受伤 / 隐藏 / 艰难 / 守光"},
    {37, "风火家人", "101011", "巽", "离", "利女贞。", "内部秩序、家庭/团队规则，先把关系理顺。", "趋势回到内部治理，宜明确角色与责任。", "家庭 / 秩序 / 内部 / 角色"},
    {38, "火泽睽", "110101", "离", "兑", "小事吉。", "分歧与异质并存，小事可行，大事需协调。", "趋势出现分歧，宜求同存异。", "分歧 / 异见 / 协调 / 小成"},
    {39, "水山蹇", "001010", "坎", "艮", "利西南，不利东北。利见大人。", "前路艰难受阻，需要绕行与求助。", "趋势走向艰难阻滞，宜换路径、找贵人。", "艰难 / 阻碍 / 绕行 / 求助"},
    {40, "雷水解", "010100", "震", "坎", "利西南。无所往，其来复吉。", "困局开始松解，适合释放压力、解决问题。", "趋势走向解除与缓和，抓住松动时机。", "解除 / 缓和 / 释放 / 解决"},
    {41, "山泽损", "110001", "艮", "兑", "有孚，元吉，无咎，可贞。", "减少、取舍、减法换长期收益。", "趋势要求做减法，舍小得大。", "减少 / 取舍 / 节省 / 修正"},
    {42, "风雷益", "100011", "巽", "震", "利有攸往，利涉大川。", "增长、增益、外部帮助到来，适合行动。", "趋势走向增益，宜趁势推进。", "增加 / 帮助 / 成长 / 推进"},
    {43, "泽天夬", "111110", "兑", "乾", "扬于王庭，孚号有厉。", "决断、摊牌、去除顽固问题，但要防鲁莽。", "趋势要求决断与公开处理，果断但别冲动。", "决断 / 摊牌 / 清除 / 果敢"},
    {44, "天风姤", "011111", "乾", "巽", "女壮，勿用取女。", "意外相遇，诱因强烈，需辨别利害。", "趋势出现突发相遇，宜谨慎应对诱惑。", "相遇 / 突发 / 诱惑 / 辨别"},
    {45, "泽地萃", "000110", "兑", "坤", "亨，王假有庙。利见大人。", "聚集资源与人心，适合会合、组织、仪式。", "趋势走向汇聚，宜建立中心与共识。", "聚集 / 会合 / 资源 / 仪式"},
    {46, "地风升", "011000", "坤", "巽", "元亨，用见大人，勿恤。", "稳步上升，循序渐进，不要急于求成。", "趋势走向上升，宜持续积累。", "上升 / 渐进 / 成长 / 积累"},
    {47, "泽水困", "010110", "兑", "坎", "亨，贞，大人吉，无咎。", "资源受限、处境困顿，保持心志可过关。", "趋势进入困境，宜守心、减耗、等转机。", "困顿 / 受限 / 坚守 / 节流"},
    {48, "水风井", "011010", "坎", "巽", "改邑不改井，无丧无得。", "基础资源与公共价值，需维护源头。", "趋势回到根本资源，宜修井养源。", "资源 / 基础 / 供给 / 维护"},
    {49, "泽火革", "101110", "兑", "离", "己日乃孚，元亨利贞。", "改革、换旧为新，时机成熟后果断改变。", "趋势走向变革，宜顺势更新制度。", "改革 / 更新 / 换代 / 时机"},
    {50, "火风鼎", "011101", "离", "巽", "元吉，亨。", "重组资源、成就新器，适合建立新秩序。", "趋势走向鼎新，宜把资源炼成成果。", "鼎新 / 转化 / 制度 / 成器"},
    {51, "震为雷", "100100", "震", "震", "亨。震来虩虩，笑言哑哑。", "震动、惊醒、突发变化，镇定后可转危为机。", "趋势带来震动，先稳住，再行动。", "震动 / 惊醒 / 变化 / 行动"},
    {52, "艮为山", "001001", "艮", "艮", "艮其背，不获其身。", "止住、静定、设边界，适合暂停与内观。", "趋势要求停止与收束，别再盲动。", "停止 / 静定 / 边界 / 克制"},
    {53, "风山渐", "001011", "巽", "艮", "女归吉，利贞。", "渐进成长，按步骤来，慢就是快。", "趋势走向渐进，宜循序推进。", "渐进 / 步骤 / 成长 / 耐心"},
    {54, "雷泽归妹", "110100", "震", "兑", "征凶，无攸利。", "关系或位置不正，贸然推进不利。", "趋势提示关系错位，宜先校正名分与条件。", "错位 / 关系 / 冲动 / 谨慎"},
    {55, "雷火丰", "101100", "震", "离", "亨，王假之，勿忧，宜日中。", "盛大丰盈、光亮达到高点，但盛极需防衰。", "趋势走向丰盛与高峰，宜把握当下。", "丰盛 / 高峰 / 光明 / 短暂"},
    {56, "火山旅", "001101", "离", "艮", "小亨，旅贞吉。", "在外、漂泊、临时状态，宜守礼低调。", "趋势进入旅途与临时局，谨慎安顿。", "旅行 / 漂泊 / 临时 / 守礼"},
    {57, "巽为风", "011011", "巽", "巽", "小亨，利有攸往，利见大人。", "柔入、渗透、沟通，慢慢影响比硬推有效。", "趋势走向渗透与沟通，宜柔性推进。", "顺入 / 沟通 / 渗透 / 柔和"},
    {58, "兑为泽", "110110", "兑", "兑", "亨，利贞。", "喜悦、交流、兑现承诺；注意别流于轻浮。", "趋势走向交流与愉悦，宜真诚表达。", "喜悦 / 交流 / 兑现 / 开放"},
    {59, "风水涣", "010011", "巽", "坎", "亨。王假有庙，利涉大川。", "涣散、分解旧结，适合疏通、重聚。", "趋势走向疏散与重组，先化解僵局。", "涣散 / 疏通 / 重组 / 化解"},
    {60, "水泽节", "110010", "坎", "兑", "亨。苦节不可贞。", "节制、规则、限度，适度约束才有效。", "趋势要求设限与节制，过度约束反而有害。", "节制 / 规则 / 限度 / 适度"},
    {61, "风泽中孚", "110011", "巽", "兑", "豚鱼吉，利涉大川。", "内在诚信感通外物，信任是关键。", "趋势走向诚信与感通，宜以诚建立连接。", "诚信 / 信任 / 感通 / 沟通"},
    {62, "雷山小过", "001100", "震", "艮", "亨，利贞。可小事，不可大事。", "小有越过，适合小事调整，不宜大举冒进。", "趋势要求小步修正，别做过大的动作。", "小过 / 修正 / 谨慎 / 小事"},
    {63, "水火既济", "101010", "坎", "离", "亨小，利贞。初吉终乱。", "事情已成但仍需维护，防止完成后的混乱。", "趋势走向完成后的维护，别掉以轻心。", "完成 / 平衡 / 维护 / 防乱"},
    {64, "火水未济", "010101", "离", "坎", "亨。小狐汔济，濡其尾，无攸利。", "未完成、临门一脚，仍需谨慎收尾。", "趋势仍未完成，宜补足最后一段。", "未完成 / 收尾 / 谨慎 / 过渡"},
};

constexpr const char *kTrigramNamesByBits[] = {
    "坤", "震", "坎", "兑", "艮", "离", "巽", "乾",
};

constexpr const char *kTrigramMnemonicsByBits[] = {
    "坤六断", "震仰盂", "坎中满", "兑上缺", "艮覆碗", "离中虚", "巽下断", "乾三连",
};
}

const IChingHexagram *getHexagramById(int id) {
  if (id < 1 || id >= static_cast<int>(sizeof(kHexagramsById) / sizeof(kHexagramsById[0]))) return nullptr;
  return &kHexagramsById[id];
}

const char *getTrigramNameByBits(uint8_t bits) {
  if (bits >= 8) return "";
  return kTrigramNamesByBits[bits];
}

const char *getTrigramMnemonicByBits(uint8_t bits) {
  if (bits >= 8) return "";
  return kTrigramMnemonicsByBits[bits];
}
